# Keil uVision project STM32F1xx_HAL.uvprojx, settings and files
target stm32f1xx_HAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32F1xx_HAL +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103xB,USE_HAL_DRIVER
  c include: ..\..\..\CORE;..\..\..\STM32F1xx_HAL_Driver\Inc;..\src;..\..\..\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\..\SYSTEM;..\..\..\FreeRTOS\include;..\..\..\FreeRTOS\portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../../../CORE/: startup_stm32f103xb.s system_stm32f1xx.c stm32f103xb.h
  group STM32F1xx_HAL_Driver
    ../../../STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_utils.c stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group FreeRTOS
    ../../../FreeRTOS/: tasks.c queue.c list.c event_groups.c timers.c heap_4.c
    ../../../FreeRTOS/portable/: port.c
  group SYSTEM
    ../../../SYSTEM/: delay.c delay.h led.c led.h key.c key.h beep.c beep.h uart_debug.c uart_debug.h i2c_scanner.c i2c_scanner.h adc_test.c adc_test.h led_all.c led_all.h oled.c oled.h wifi_test.c wifi_test.h bt_test.c bt_test.h uart_scan.c uart_scan.h dht11.c dht11.h ds3231.c ds3231.h mq135.c mq135.h light.c light.h pir.c pir.h chinese_font.h mqtt.c mqtt.h servo.c servo.h door.c door.h
  group USER
    ../src/: main.c stm32f1xx_it.c stm32f1xx_it.h stm32f1xx_hal_conf.h
